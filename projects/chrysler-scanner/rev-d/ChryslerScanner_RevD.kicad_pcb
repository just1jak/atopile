# Repository just1jak/atopile (continued)

## KiCad design projects/chrysler-scanner/rev-d/ChryslerScanner_RevD.kicad_pcb (continued)

Schematic: 22_sd-logger.kicad_sch, Integrated microSD logging hardware

Parts:
C58, C59: 10uF; C_0805_2012Metric; Selected Voltage Rating 16V; Tolerance 10%; MPN CGA4J1X5R1C106K125AC
C60: 100nF; C_0603_1608Metric; Selected Voltage Rating 50V; Tolerance 10%; MPN C0603C104K5RACTU
C61: 100uF; CP_Elec_5x5.9; Selected Voltage Rating 6.3V; Tolerance 20%; MPN 6SVPC100M
J4: microSD / DM3AT-SF-PEJM5; microSD_HC_Hirose_DM3AT-SF-PEJM5; MPN DM3AT-SF-PEJM5
R104, R105, R106: 33R; R_0603_1608Metric; Tolerance 1%; MPN CRCW060333R0FKEA
R107, R108, R109, R110, R111, R113, R114: 10k; R_0603_1608Metric; Tolerance 1%; MPN CRCW060310K0FKEA
R112: 47k; R_0603_1608Metric; Tolerance 1%; MPN CRCW060347K0FKEA
SW3: LOG / SAFE STOP; SW_SPST_TL3305A; MPN TL3305AF160QG
U20: MCP1825S-3302E/DB; SOT-223-3_TabPin2; MPN MCP1825S-3302E/DB

Connections:
+3.3V: R112.1, R113.1, R114.1; also elsewhere on the board
+5V: C58.1, U20.1 (VI); also elsewhere on the board
GND: C58.2, C59.2, C60.2, C61.2, J4.6 (VSS), J4.10 (DET_A), J4.SH (SHIELD), SW3.2, U20.2 (GND); also elsewhere on the board
LOG_BUTTON: R113.2, SW3.1; also elsewhere on the board
MCU_SD_CS: R106.1, R112.2; also elsewhere on the board
MCU_SD_MOSI: R105.1; also elsewhere on the board
MCU_SD_SCK: R104.1; also elsewhere on the board
SD_3V3: C59.1, C60.1, C61.1, J4.4 (VDD), R107.1, R108.1, R109.1, R110.1, R111.1, U20.3 (VO); also elsewhere on the board
SD_CS: J4.2 (DAT3/CD), R106.2, R107.2; also elsewhere on the board
SD_DAT1: J4.8 (DAT1), R110.2
SD_DAT2: J4.1 (DAT2), R111.2
SD_DETECT: J4.9 (DET_B), R114.2; also elsewhere on the board
SD_MISO: J4.7 (DAT0), R109.2; also elsewhere on the board
SD_MOSI: J4.3 (CMD), R105.2, R108.2; also elsewhere on the board
SD_SCK: J4.5 (CLK), R104.2; also elsewhere on the board

Notes on the sheet:
GPIO15 CS is biased high at reset; GPIO12 and GPIO2 remain unused.
Existing ESP32-PICO-V3-02 | removable storage | native scanner functions retained | firmware deferred
Card-detect input
GPIO20 is package-specific; use ESP-IDF support for ESP32-PICO-V3.
SD rail transient current and total +5 V budget need hardware validation.
SD CMD/DAT pull-ups / MCU CS strap bias
GPIO36/37/38 are input-only and have external pull-ups.
Dedicated 3.3 V SD supply from the existing +5 V rail
Bulk capacitance is not a safe-power-off hold-up supply.
On-board microSD logger (SPI)
Existing sheets use passive visualization pins; native ERC is not independent certification of the scanner circuit.
J4: Hirose DM3AT-SF-PEJM5 / SPI mode
Active-low record / safe-stop input
Firmware deferred: this hardware revision does not yet record data.
ACT_LED / GPIO13 is reserved for the supervised health heartbeat. No SD/activity writers, autonomous blink, PWM or DMA may drive this pin.
MCU-side series damping

Schematic: 08_power-5v.kicad_sch, 5 V / 3.3 V supplies

Parts:
C4: 10μF; C_1206_3216Metric; Voltage Rating 50V; Selected Voltage Rating 50V; MPN CGA5L1X7R1H106K160AC
C5: 0.1μF; C_1206_3216Metric; Voltage Rating 100V; Selected Voltage Rating 100V; MPN C1206C104K1RACTU
C6, C8, C10: 22μF; C_1206_3216Metric; Voltage Rating 25V; Selected Voltage Rating 25V; MPN C3216X5R1E226M160AB
C7, C9: 10μF; C_1206_3216Metric; Voltage Rating 25V; Selected Voltage Rating 50V; MPN CGA5L1X7R1H106K160AC
D4, D5, D6: DSK34; D_SOD-123; MPN DSK34
L1: 22µH; L_Eaton_DR74_Recommended; MPN DR74-220-R
R1: 100kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW0603100KFKEA
R2: 68kΩ; R_0603_1608Metric; Tolerance 0.1%; MPN TNPW060368K0BEEA
R3: 10kΩ; R_0603_1608Metric; Tolerance 0.1%; MPN TNPW060310K0BEEA
U2: LMR14010; SOT-23-6; MPN LMR14010ADDCR
U3: TLV76750DRV; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; MPN TLV76750DRVR
U4: TLV76733DRV; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; MPN TLV76733DRVR

Connections:
+3.3V: C10.1, D6.2, U4.1, U4.2; also elsewhere on the board
+5V: C8.1, C9.1, D5.2, D6.1, U3.1, U3.2, U4.4, U4.6; also elsewhere on the board
+12V: C4.1, R1.1, U2.5; also elsewhere on the board
GND: C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, D4.2, R3.2, U2.2, U3.3, U3.5, U3.7, U4.3, U4.5, U4.7; also elsewhere on the board
N_C5_1: C5.1, U2.1
N_C5_2: C5.2, D4.1, L1.1, U2.6
N_R1_2: R1.2, U2.4
N_R2_1: C6.1, C7.1, D5.1, L1.2, R2.1, U3.4, U3.6
N_R3_1: R2.2, R3.1, U2.3

Notes on the sheet:
Atopile source / editable KiCad view / passive pins require electrical review.
Native schematic and PCB ground connectivity are checked in the final validation reports.
All TLV767 ground terminals and exposed pads connect to GND in this checked revision.
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.
5 V / 3.3 V supplies

Schematic: 03_sci-14-9.kicad_sch, SCI TX14 / TX9

Parts:
C41: 0.1μF; C_0603_1608Metric; Selected Voltage Rating 50V; Tolerance 10%; MPN C0603C104K5RACTU
Q3: DMN62D2UDM; SOT-23-6; MPN DMN62D2UDM-7
R36, R39: 4.7kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW06034K70FKEA
R37, R40: 4.7kΩ; R_1206_3216Metric; Tolerance 1%; MPN CRCW12064K70FKEA
R38, R41: 10kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW060310K0FKEA
U14: 74LVC2G66; VSSOP-8_2.3x2mm_P0.5mm; MPN SN74LVC2G66DCTR

Connections:
+3.3V: C41.1, Q3.2, Q3.5, R37.1, R40.2, U14.8; also elsewhere on the board
+5V: R36.1, R39.2; also elsewhere on the board
GND: C41.2, R38.1, R41.2, U14.4; also elsewhere on the board
J1962-9: Q3.3, R39.1; also elsewhere on the board
LEGACY_14_ISOLATED: Q3.6, R36.2; also elsewhere on the board
N_R37_2: Q3.1, R37.2, U14.2
N_R40_1: Q3.4, R40.1, U14.6
TX2: U14.1, U14.5; also elsewhere on the board
TX9_EN: R41.1, U14.3; also elsewhere on the board
TX14_EN: R38.2, U14.7; also elsewhere on the board

Notes on the sheet:
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.
SCI TX14 / TX9
Atopile source / editable KiCad view / passive pins require electrical review.

Schematic: 17_adc.kicad_sch, Voltage monitoring

Parts:
C47, C48, C49: 0.1μF; C_0603_1608Metric; Selected Voltage Rating 50V; Tolerance 10%; MPN C0603C104K5RACTU
D27, D28, D29: PESD3V3U1UA; D_SOD-323; MPN PESD3V3U1UA,115
R49, R51, R53: 22k 1%; R_0603_1608Metric; Tolerance 1%; MPN CRCW060322K0FKEA
R50, R52, R54: 1.62k 1%; R_0603_1608Metric; Tolerance 1%; MPN CRCW06031K62FKEA

Connections:
+12V: R49.1; also elsewhere on the board
GND: C47.2, C48.2, C49.2, D27.2, D28.2, D29.2, R50.2, R52.2, R54.2; also elsewhere on the board
VBB: R51.1; also elsewhere on the board
VPP: R53.1; also elsewhere on the board
V_BA_PRE: C47.1, D27.1, R49.2, R50.1; also elsewhere on the board
V_BT_PRE: C48.1, D28.1, R51.2, R52.1; also elsewhere on the board
V_PR_PRE: C49.1, D29.1, R53.2, R54.1; also elsewhere on the board

Notes on the sheet:
Voltage monitoring
Atopile source / editable KiCad view / passive pins require electrical review.
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.
Rev C: 22k / (1.62k || 100k), nominal ADC/input gain = 0.06757. Calibrate switch leakage/resistance, tolerances and ADC response. V_BA senses protected +12V after D2; connector voltage needs diode-drop correction. Original 8.66k divider conversion constants do not apply.

Schematic: 20_leds.kicad_sch, Status LED drivers

Parts:
D23: RED; LED_V140_Reference; MPN LTST-C150KRKT
D24: YELLOW; LED_V140_Reference; MPN LTST-C150KSKT
D25: GREEN; LED_V140_Reference; MPN LTST-C150KGKT
D26: BLUE; LED_V140_Reference; MPN LTST-C150TBKT
Q17, Q18, Q19, Q20: AO3400; SOT-23; MPN AO3400A
R89, R95: 470Ω; R_0603_1608Metric; Tolerance 1%; MPN CRCW0603470RFKEA
R90, R92, R94, R96: 10kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW060310K0FKEA
R91: 300Ω; R_0603_1608Metric; Tolerance 1%; MPN CRCW0603300RFKEA
R93: 1kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW06031K00FKEA

Connections:
+3.3V: R94.2; also elsewhere on the board
+5V: R89.1, R91.1, R93.1, R95.1; also elsewhere on the board
ACT_LED: Q20.1, R96.1; also elsewhere on the board
GND: Q17.2, Q18.2, Q19.2, Q20.2, R90.2, R92.2, R96.2; also elsewhere on the board
N_Q17_3: D23.1, Q17.3
N_Q18_3: D24.1, Q18.3
N_Q19_3: D25.1, Q19.3
N_Q20_3: D26.1, Q20.3
N_R89_2: D23.2, R89.2
N_R91_2: D24.2, R91.2
N_R93_2: D25.2, R93.2
N_R95_2: D26.2, R95.2
PWR_LED: Q19.1, R94.1; also elsewhere on the board
RX_LED: Q17.1, R90.1; also elsewhere on the board
TX_LED: Q18.1, R92.1; also elsewhere on the board

Notes on the sheet:
Status LED drivers
Atopile source / editable KiCad view / passive pins require electrical review.
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.

Schematic: 09_power-vpp.kicad_sch, VPP boost supply

Parts:
C13, C15, C16: 10μF; C_1206_3216Metric; Voltage Rating 50V; Selected Voltage Rating 50V; MPN CGA5L1X7R1H106K160AC
C14: 22μF; C_2220_5750_TDK_22u50V; Voltage Rating 50V; Selected Voltage Rating 50V; MPN CGA9P3X7R1H226MT0Y0N
D7: DSK34; D_SOD-123; MPN DSK34
L2: 22µH; L_Eaton_DR74_Recommended; MPN DR74-220-R
L3: 240nH; L_Bourns_SRN2012; MPN SRN2012-R24M
R8: 110kΩ; R_0603_1608Metric; Tolerance 0.1%; MPN TNPW0603110KBEEA
R9: 6.8kΩ; R_0603_1608Metric; Tolerance 0.1%; MPN TNPW06036K80BEEA
U5: LGS6302; SOT-23-5; MPN LGS6302B5

Connections:
+5V: U5.4; also elsewhere on the board
+12V: C13.1, L2.1, U5.5; also elsewhere on the board
GND: C13.2, C14.2, C15.2, C16.2, R9.2, U5.2; also elsewhere on the board
N_D7_2: D7.2, L2.2, U5.1
N_R8_1: C14.1, D7.1, L3.1, R8.1
N_R8_2: R8.2, R9.1, U5.3
VPP: C15.1, C16.1, L3.2; also elsewhere on the board

Notes on the sheet:
Atopile source / editable KiCad view / passive pins require electrical review.
VPP boost supply
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.

Schematic: 04_sci-6-12.kicad_sch, SCI TX6 / TX12 + RX bias

Parts:
C38: 0.1μF; C_0603_1608Metric; Selected Voltage Rating 50V; Tolerance 10%; MPN C0603C104K5RACTU
Q2: DMN62D2UDM; SOT-23-6; MPN DMN62D2UDM-7
Q6: CJ3439KDW; SOT-363_SC-70-6_RR; MPN CJ3439KDW
R29, R30, R33: 4.7kΩ; R_1206_3216Metric; Tolerance 1%; MPN CRCW12064K70FKEA
R31, R34, R75: 10kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW060310K0FKEA
R32, R76: 4.7kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW06034K70FKEA
U13: 74LVC2G66; VSSOP-8_2.3x2mm_P0.5mm; MPN SN74LVC2G66DCTR

Connections:
+3.3V: C38.1, Q2.2, Q2.5, R30.1, R33.2, U13.8; also elsewhere on the board
+5V: Q6.4, R29.1, R32.2, R76.1; also elsewhere on the board
GND: C38.2, Q6.1, R31.1, R34.2, R75.2, U13.4; also elsewhere on the board
J1962-12: Q2.3, R32.1; also elsewhere on the board
LEGACY_6_ISOLATED: Q2.6, R29.2; also elsewhere on the board
N_R30_2: Q2.1, R30.2, U13.2
N_R33_1: Q2.4, R33.1, U13.6
N_R76_2: Q6.5, Q6.6, R76.2
RX7_BIAS: Q6.3; also elsewhere on the board
RX7_BIAS_EN: Q6.2, R75.1; also elsewhere on the board
TX2: U13.1, U13.5; also elsewhere on the board
TX6_EN: R31.2, U13.7; also elsewhere on the board
TX12_EN: R34.1, U13.3; also elsewhere on the board

Notes on the sheet:
SCI TX6 / TX12 + RX bias
Atopile source / editable KiCad view / passive pins require electrical review.
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.

Schematic: 12_program-6.kicad_sch, SCI TX6 VBB / VPP drivers

Parts:
D15, D19: PMEG4005; D_SOD-123; MPN PMEG4005EGWX
Q8, Q12: DMG6601LVT-7; SOT-23-6; MPN DMG6601LVT-7
R55, R63: 10kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW060310K0FKEA
R56: 4.7kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW06034K70FKEA
R64: 4.7k 1%; R_0603_1608Metric; Tolerance 1%; MPN CRCW06034K70FKEA
R65, R124: 8.2k 1%; R_0603_1608Metric; Tolerance 1%; MPN CRCW06038K20FKEA

Connections:
GND: Q8.5, Q12.5, R55.2, R63.2; also elsewhere on the board
LEGACY_6_ISOLATED: D15.1, D19.1; also elsewhere on the board
N_Q8B_4: D15.2, Q8.4
N_Q12B_4: D19.2, Q12.4
N_R56_2: Q8.3, R56.2, R124.2
N_R64_2: Q12.3, R64.2, R65.1
N_R65_2: Q12.6, R65.2
N_R124_1: Q8.6, R124.1
VBB: Q8.2, R56.1; also elsewhere on the board
VBB_TO_TX6: Q8.1, R55.1; also elsewhere on the board
VPP: Q12.2, R64.1; also elsewhere on the board
VPP_TO_TX6: Q12.1, R63.1; also elsewhere on the board

Notes on the sheet:
Atopile source / editable KiCad view / passive pins require electrical review.
SCI TX6 VBB / VPP drivers
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.
VBB gate divider: 4.7k / 8.2k limits |Vgs| to 10.34V at the bounded 28V peak. AW9523 P0 must be configured push-pull; startup/default controls stay low.

Schematic: 13_program-9.kicad_sch, SCI TX9 VBB / VPP drivers

Parts:
D16, D20: PMEG4005; D_SOD-123; MPN PMEG4005EGWX
Q9, Q13: DMG6601LVT-7; SOT-23-6; MPN DMG6601LVT-7
R57, R66: 10kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW060310K0FKEA
R58: 4.7kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW06034K70FKEA
R67: 4.7k 1%; R_0603_1608Metric; Tolerance 1%; MPN CRCW06034K70FKEA
R68, R125: 8.2k 1%; R_0603_1608Metric; Tolerance 1%; MPN CRCW06038K20FKEA

Connections:
GND: Q9.5, Q13.5, R57.2, R66.2; also elsewhere on the board
J1962-9: D16.1, D20.1; also elsewhere on the board
N_Q9B_4: D16.2, Q9.4
N_Q13B_4: D20.2, Q13.4
N_R58_2: Q9.3, R58.2, R125.2
N_R67_2: Q13.3, R67.2, R68.1
N_R68_2: Q13.6, R68.2
N_R125_1: Q9.6, R125.1
VBB: Q9.2, R58.1; also elsewhere on the board
VBB_TO_TX9: Q9.1, R57.1; also elsewhere on the board
VPP: Q13.2, R67.1; also elsewhere on the board
VPP_TO_TX9: Q13.1, R66.1; also elsewhere on the board

Notes on the sheet:
SCI TX9 VBB / VPP drivers
Atopile source / editable KiCad view / passive pins require electrical review.
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.
VBB gate divider: 4.7k / 8.2k limits |Vgs| to 10.34V at the bounded 28V peak. AW9523 P0 must be configured push-pull; startup/default controls stay low.

Schematic: 10_power-vbb.kicad_sch, VBB supply

Parts:
C17: 0.1μF; C_1206_3216Metric; Voltage Rating 100V; Selected Voltage Rating 100V; MPN C1206C104K1RACTU
C18: 22μF; C_1206_3216Metric; Voltage Rating 25V; Selected Voltage Rating 25V; MPN C3216X5R1E226M160AB
C19: 10μF; C_1206_3216Metric; Voltage Rating 25V; Selected Voltage Rating 50V; MPN CGA5L1X7R1H106K160AC
D8: DSK34; D_SOD-123; MPN DSK34
L4: 22µH; L_Eaton_DR74_Recommended; MPN DR74-220-R
L5: 470nH; L_Bourns_SRN2012; MPN SRN2012-R47M
R10: 100kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW0603100KFKEA
R11: 158kΩ; R_0603_1608Metric; Tolerance 0.1%; MPN TNPW0603158KBEEA
R12: 10kΩ; R_0603_1608Metric; Tolerance 0.1%; MPN TNPW060310K0BEEA
U6: LMR14010; SOT-23-6; MPN LMR14010ADDCR

Connections:
GND: C18.2, C19.2, D8.2, R12.2, U6.2; also elsewhere on the board
N_C17_1: C17.1, U6.1
N_C17_2: C17.2, D8.1, L4.1, U6.6
N_R10_2: R10.2, U6.4
N_R11_1: C18.1, L4.2, L5.1, R11.1
N_R11_2: R11.2, R12.1, U6.3
VBB: C19.1, L5.2; also elsewhere on the board
VPP: R10.1, U6.5; also elsewhere on the board

Notes on the sheet:
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.
VBB supply
Atopile source / editable KiCad view / passive pins require electrical review.

Schematic: 05_sci-rx.kicad_sch, SCI RX7 / RX15

Parts:
C43: 0.1μF; C_0603_1608Metric; Selected Voltage Rating 50V; Tolerance 10%; MPN C0603C104K5RACTU
Q4: DMN62D2UDM; SOT-23-6; MPN DMN62D2UDM-7
R42, R45: 1kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW06031K00FKEA
R43, R46: 4.7kΩ; R_1206_3216Metric; Tolerance 1%; MPN CRCW12064K70FKEA
R44, R47: 10kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW060310K0FKEA
U15: 74LVC2G66; VSSOP-8_2.3x2mm_P0.5mm; MPN SN74LVC2G66DCTR

Connections:
+3.3V: C43.1, Q4.2, Q4.5, R43.1, R46.1, U15.8; also elsewhere on the board
+5V: R45.1; also elsewhere on the board
GND: C43.2, R44.1, R47.1, U15.4; also elsewhere on the board
J1962-7: Q4.6, R42.2; also elsewhere on the board
J1962-15: Q4.3, R45.2; also elsewhere on the board
N_R43_2: Q4.1, R43.2, U15.2
N_R46_2: Q4.4, R46.2, U15.6
RX2: U15.1, U15.5; also elsewhere on the board
RX7_BIAS: R42.1; also elsewhere on the board
RX7_EN: R44.2, U15.7; also elsewhere on the board
RX15_EN: R47.2, U15.3; also elsewhere on the board

Notes on the sheet:
Atopile source / editable KiCad view / passive pins require electrical review.
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.
SCI RX7 / RX15

Schematic: 14_program-12.kicad_sch, SCI TX12 VBB / VPP drivers

Parts:
D17, D21: PMEG4005; D_SOD-123; MPN PMEG4005EGWX
Q10, Q14: DMG6601LVT-7; SOT-23-6; MPN DMG6601LVT-7
R59, R69: 10kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW060310K0FKEA
R60: 4.7kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW06034K70FKEA
R70: 4.7k 1%; R_0603_1608Metric; Tolerance 1%; MPN CRCW06034K70FKEA
R71, R126: 8.2k 1%; R_0603_1608Metric; Tolerance 1%; MPN CRCW06038K20FKEA

Connections:
GND: Q10.5, Q14.5, R59.2, R69.2; also elsewhere on the board
J1962-12: D17.1, D21.1; also elsewhere on the board
N_Q10B_4: D17.2, Q10.4
N_Q14B_4: D21.2, Q14.4
N_R60_2: Q10.3, R60.2, R126.2
N_R70_2: Q14.3, R70.2, R71.1
N_R71_2: Q14.6, R71.2
N_R126_1: Q10.6, R126.1
VBB: Q10.2, R60.1; also elsewhere on the board
VBB_TO_TX12: Q10.1, R59.1; also elsewhere on the board
VPP: Q14.2, R70.1; also elsewhere on the board
VPP_TO_TX12: Q14.1, R69.1; also elsewhere on the board

Notes on the sheet:
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.
SCI TX12 VBB / VPP drivers
Atopile source / editable KiCad view / passive pins require electrical review.
VBB gate divider: 4.7k / 8.2k limits |Vgs| to 10.34V at the bounded 28V peak. AW9523 P0 must be configured push-pull; startup/default controls stay low.

Schematic: 15_program-14.kicad_sch, SCI TX14 VBB / VPP drivers

Parts:
D18, D22: PMEG4005; D_SOD-123; MPN PMEG4005EGWX
Q11, Q15: DMG6601LVT-7; SOT-23-6; MPN DMG6601LVT-7
R61, R72: 10kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW060310K0FKEA
R62: 4.7kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW06034K70FKEA
R73: 4.7k 1%; R_0603_1608Metric; Tolerance 1%; MPN CRCW06034K70FKEA
R74, R127: 8.2k 1%; R_0603_1608Metric; Tolerance 1%; MPN CRCW06038K20FKEA

Connections:
GND: Q11.5, Q15.5, R61.2, R72.2; also elsewhere on the board
LEGACY_14_ISOLATED: D18.1, D22.1; also elsewhere on the board
N_Q11B_4: D18.2, Q11.4
N_Q15B_4: D22.2, Q15.4
N_R62_2: Q11.3, R62.2, R127.2
N_R73_2: Q15.3, R73.2, R74.1
N_R74_2: Q15.6, R74.2
N_R127_1: Q11.6, R127.1
VBB: Q11.2, R62.1; also elsewhere on the board
VBB_TO_TX14: Q11.1, R61.1; also elsewhere on the board
VPP: Q15.2, R73.1; also elsewhere on the board
VPP_TO_TX14: Q15.1, R72.1; also elsewhere on the board

Notes on the sheet:
SCI TX14 VBB / VPP drivers
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.
Atopile source / editable KiCad view / passive pins require electrical review.
VBB gate divider: 4.7k / 8.2k limits |Vgs| to 10.34V at the bounded 28V peak. AW9523 P0 must be configured push-pull; startup/default controls stay low.

Schematic: 11_power-7v5.kicad_sch, 7.5 V supply

Parts:
C20: 10μF; C_1206_3216Metric; Voltage Rating 50V; Selected Voltage Rating 50V; MPN CGA5L1X7R1H106K160AC
C21: 0.1μF; C_1206_3216Metric; Voltage Rating 100V; Selected Voltage Rating 100V; MPN C1206C104K1RACTU
C22, C24: 22μF; C_1206_3216Metric; Voltage Rating 25V; Selected Voltage Rating 25V; MPN C3216X5R1E226M160AB
C23: 10μF; C_1206_3216Metric; Voltage Rating 25V; Selected Voltage Rating 50V; MPN CGA5L1X7R1H106K160AC
D9, D10: DSK34; D_SOD-123; MPN DSK34
L6: 22µH; L_Eaton_DR74_Recommended; MPN DR74-220-R
R13: 100kΩ; R_0603_1608Metric; Tolerance 1%; MPN CRCW0603100KFKEA
R14: 100kΩ; R_0603_1608Metric; Tolerance 0.1%; MPN TNPW0603100KBEEA
R15, R17: 10kΩ; R_0603_1608Metric; Tolerance 0.1%; MPN TNPW060310K0BEEA
R16: 82.5kΩ; R_0603_1608Metric; Tolerance 0.1%; MPN TNPW060382K5BEEA
U7: LMR14010; SOT-23-6; MPN LMR14010ADDCR
U8: TLV76701DRV; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; MPN TLV76701DRVR

Connections:
+7.5V: C24.1, D10.2, R16.1, U8.1; also elsewhere on the board
+12V: C20.1, R13.1, U7.5; also elsewhere on the board
GND: C20.2, C22.2, C23.2, C24.2, D9.2, R15.2, R17.2, U7.2, U8.3, U8.5, U8.7; also elsewhere on the board
N_C21_1: C21.1, U7.1
N_C21_2: C21.2, D9.1, L6.1, U7.6
N_R13_2: R13.2, U7.4
N_R14_1: C22.1, C23.1, D10.1, L6.2, R14.1, U8.4, U8.6
N_R14_2: R14.2, R15.1, U7.3
N_R16_2: R16.2, R17.1, U8.2

Notes on the sheet:
All TLV767 ground terminals and exposed pads connect to GND in this checked revision.
7.5 V supply
Matching signal names connect between sheets. Values and package pins follow the atopile netlist.
Native schematic and PCB ground connectivity are checked in the final validation reports.
Atopile source / editable KiCad view / passive pins require electrical review.

Schematic: 24_debug-testpoints.kicad_sch, Debug access / hook test points

Parts:
TP1: J1962-16; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP2: +12V; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP3: VBUS; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP4: +5V; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP5: +3.3V; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP6: SD_3V3; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP7: +7.5V; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP8: VBB; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP9: VPP; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP10: PCI_VCC; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP11: J1962-2; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP12: J1962-3; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP13: J1962-11; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP14: LEGACY_6_ISOLATED; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP15: J1962-12; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP16: LEGACY_14_ISOLATED; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP17: J1962-9; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP18: J1962-7; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP19: J1962-15; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP20: TX0; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP21: RX0; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP22: EN; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP23: IO0; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP24: SCL; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP25: SDA; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP26: PCI_RX; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP27: PCI_TX; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP28: RX1; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP29: TX1; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP30: RX2; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP31: TX2; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP32: ACT_LED; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP33: HEARTBEAT_VALID; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP34: LOGIC_PG; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP35: N_R88_2; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP36: V_BA_PRE; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP37: V_BA; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP38: V_BT_PRE; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP39: V_BT; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP40: V_PR_PRE; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP41: V_PR; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP42: SD_DETECT; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP43: CCD+; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP44: CCD-; TestPoint_Keystone_5015_Micro_Mini; MPN 5015
TP45: SD_CS; TestPoint_Pad_D1.0mm; MPN COPPER_PAD_NO_COMPONENT
TP46: SD_SCK; TestPoint_Pad_D1.0mm; MPN COPPER_PAD_NO_COMPONENT
TP47: SD_MOSI; TestPoint_Pad_D1.0mm; MPN COPPER_PAD_NO_COMPONENT
TP48: SD_MISO; TestPoint_Pad_D1.0mm; MPN COPPER_PAD_NO_COMPONENT
TP49, TP50, TP51, TP52: GND; TestPoint_Keystone_5015_Micro_Mini; MPN 5015

Connections:
+3.3V: TP5.1; also elsewhere on the board
+5V: TP4.1; also elsewhere on the board
+7.5V: TP7.1; also elsewhere on the board
+12V: TP2.1; also elsewhere on the board
ACT_LED: TP32.1; also elsewhere on the board
CCD+: TP43.1; also elsewhere on the board
CCD-: TP44.1; also elsewhere on the board
EN: TP22.1; also elsewhere on the board
GND: TP49.1, TP50.1, TP51.1, TP52.1; also elsewhere on the board
HEARTBEAT_VALID: TP33.1; also elsewhere on the board
IO0: TP23.1; also elsewhere on the board
J1962-2: TP11.1; also elsewhere on the board
J1962-3: TP12.1; also elsewhere on the board
J1962-7: TP18.1; also elsewhere on the board
J1962-9: TP17.1; also elsewhere on the board
J1962-11: TP13.1; also elsewhere on the board
J1962-12: TP15.1; also elsewhere on the board
J1962-15: TP19.1; also elsewhere on the board
J1962-16: TP1.1; also elsewhere on the board
LEGACY_6_ISOLATED: TP14.1; also elsewhere on the board
LEGACY_14_ISOLATED: TP16.1; also elsewhere on the board
LOGIC_PG: TP34.1; also elsewhere on the board
N_R88_2: TP35.1; also elsewhere on the board
PCI_RX: TP26.1; also elsewhere on the board
PCI_TX: TP27.1; also elsewhere on the board
PCI_VCC: TP10.1; also elsewhere on the board
RX0: TP21.1; also elsewhere on the board
RX1: TP28.1; also elsewhere on the board
RX2: TP30.1; also elsewhere on the board
SCL: TP24.1; also elsewhere on the board
SDA: TP25.1; also elsewhere on the board
SD_3V3: TP6.1; also elsewhere on the board
SD_CS: TP45.1; also elsewhere on the board
SD_DETECT: TP42.1; also elsewhere on the board
SD_MISO: TP48.1; also elsewhere on the board
SD_MOSI: TP47.1; also elsewhere on the board
SD_SCK: TP46.1; also elsewhere on the board
TX0: TP20.1; also elsewhere on the board
TX1: TP29.1; also elsewhere on the board
TX2: TP31.1; also elsewhere on the board
VBB: TP8.1; also elsewhere on the board
VBUS: TP3.1; also elsewhere on the board
VPP: TP9.1; also elsewhere on the board
V_BA: TP37.1; also elsewhere on the board
V_BA_PRE: TP36.1; also elsewhere on the board
V_BT: TP39.1; also elsewhere on the board
V_BT_PRE: TP38.1; also elsewhere on the board
V_PR: TP41.1; also elsewhere on the board
V_PR_PRE: TP40.1; also elsewhere on the board

Notes on the sheet:
DEBUG ACCESS — TP1–TP52
5015 SMT hook loops; TP45–TP48 are bare SPI probe pads. Numbered silkscreen references map to nets here.

Schematic: 25_passive-can.kicad_sch, Rev D passive CAN receiver

Parts:
C140, C141: 100n; C_0603_1608Metric
D40: PESD2CANFD36VT-Q; SOT-23
U25: TCAN1042HGVDRQ1; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C141.1, U25.5 (VIO); also elsewhere on the board
+5V: C140.1, U25.3 (VCC); also elsewhere on the board
CAN_BRANCH_H: D40.1 (CANH), U25.7 (CANH); also elsewhere on the board
CAN_BRANCH_L: D40.2 (CANL), U25.6 (CANL); also elsewhere on the board
CAN_PHY_TXD: U25.1 (TXD); also elsewhere on the board
CAN_RX: U25.4 (RXD); also elsewhere on the board
CAN_STB: U25.8 (STB); also elsewhere on the board
GND: C140.2, C141.2, D40.3 (GND), U25.2 (GND); also elsewhere on the board

Notes on the sheet:
REV D / PASSIVE CAN RECEIVER
CAN branch connects to OBD pins 6/14 only through the selector on sheet 26.
TXD is recessive until the hardware permit on sheet 27 enables it. No fitted bus termination.
Prototype only. Verify protection energy, reset behavior, routing and listen-only firmware on the bench.

Schematic: 26_obd-selector.kicad_sch, Rev D software controlled OBD selector

Parts:
C142, C143, C144: 100n; C_0603_1608Metric
C145, C146: 1u / X7R; C_0603_1608Metric
D41, D42: PMEG2010EA; D_SOD-323
D43, D44: 1N5819HW-7-F; D_SOD-123
K1, K2: G6K-2F-Y DC5; Relay_DPDT_Omron_G6K-2F-Y
Q25, Q26, Q27, Q28: AO3400A; SOT-23
R140, R141: 47k; R_0603_1608Metric
R142, R143, R145: 100k; R_0603_1608Metric
R144: 10k; R_0603_1608Metric
U26: MCP23008T-E/SO; SOIC-18W_7.5x11.6mm_P1.27mm
U27: SN74HC238DR; SOIC-16_3.9x9.9mm_P1.27mm
U28: SN74LVC2G17DBVR; SOT-23-6

Connections:
+3.3V: C142.1, C143.1, C144.1, R144.1, U26.18 (VDD), U27.16 (VCC), U28.5 (VCC); also elsewhere on the board
+5V: D43.1 (K), D44.1 (K), K1.1 (COIL +), K2.1 (COIL +); also elsewhere on the board
CAN_COIL_LOW: D43.2 (A), K1.8 (COIL -), Q25.3 (D)
CAN_DECODE: D41.1 (K), R142.1, U27.14 (Y1); also elsewhere on the board
CAN_DELAY: C145.1, D41.2 (A), R142.2, U28.1 (1A)
CAN_GATE: Q25.1 (G), Q28.1 (G), U28.6 (1Y); also elsewhere on the board
CAN_SERIES_6: K1.4 (NO A); also elsewhere on the board
CAN_SERIES_14: K1.5 (NO B); also elsewhere on the board
CAN_STB: Q28.3 (D), R144.2; also elsewhere on the board
CAN_TX_ARM: U26.12 (GP2); also elsewhere on the board
COIL_RETURN: Q25.2 (S), Q26.2 (S), Q27.3 (D)
GND: C142.2, C143.2, C144.2, C145.2, C146.2, Q27.2 (S), Q28.2 (S), R140.2, R141.2, R145.2, U26.3 (A2), U26.4 (A1), U26.5 (A0), U26.9 (VSS), U27.3 (C), U27.4 (G2A_N), U27.5 (G2B_N), U27.8 (GND), U28.2 (GND); also elsewhere on the board
LEG_COIL_LOW: D44.2 (A), K2.8 (COIL -), Q26.3 (D)
LEG_DECODE: D42.1 (K), R143.1, U27.13 (Y2); also elsewhere on the board
LEG_DELAY: C146.1, D42.2 (A), R143.2, U28.3 (2A)
LEG_GATE: Q26.1 (G), U28.4 (2Y); also elsewhere on the board
LEG_SERIES_6: K2.4 (NO A); also elsewhere on the board
LEG_SERIES_14: K2.5 (NO B); also elsewhere on the board
N_R88_2: Q27.1 (G), R145.1, U26.6 (RESET_N), U27.6 (G1); also elsewhere on the board
OBD_SHARED_6: K1.3 (COM A), K2.3 (COM A); also elsewhere on the board
OBD_SHARED_14: K1.6 (COM B), K2.6 (COM B); also elsewhere on the board
REQ_CAN: R140.1, U26.10 (GP0), U27.1 (A)
REQ_LEGACY: R141.1, U26.11 (GP1), U27.2 (B)
SCL: U26.1 (SCL); also elsewhere on the board
SDA: U26.2 (SDA); also elsewhere on the board

Notes on the sheet:
OBD pins 6 / 14 mode selector
One-hot request: GP0 CAN, GP1 Legacy. 00 and 11 open both branches.
Delayed pickup / quick release. Measure dead time with the fitted flyback network.
Bench prototype. Validate coil and contact timing, supply sequencing and stuck-contact behavior.

Schematic: 27_can-tx-permit.kicad_sch, Rev D CAN hardware transmit permit

Parts:
C147, C148, C149, C150: 100n; C_0603_1608Metric
R146, R147, R148: 47k; R_0603_1608Metric
R149: 4.7k; R_0603_1608Metric
U29, U31: SN74LVC1G11DBVR; SOT-23-6
U30: SN74LVC1G04DBVR; SOT-23-5
U32: SN74LVC1G126DBVR; SOT-23-5

Connections:
+3.3V: C147.1, C148.1, C149.1, C150.1, R149.1, U29.5 (VCC), U30.5 (VCC), U31.5 (VCC), U32.5 (VCC); also elsewhere on the board
CAN_ARM_TIMED: U31.6 (C); also elsewhere on the board
CAN_DECODE: U29.3 (B); also elsewhere on the board
CAN_GATE: U29.6 (C); also elsewhere on the board
CAN_PHY_TXD: R149.2, U32.4 (Y); also elsewhere on the board
CAN_ROUTE_OK: U29.4 (Y), U31.1 (A)
CAN_TX_ARM: R146.1; also elsewhere on the board
CAN_TX_PERMIT: R147.1, U31.4 (Y), U32.1 (OE)
GND: C147.2, C148.2, C149.2, C150.2, R146.2, R147.2, R148.2, U29.2 (GND), U30.3 (GND), U31.2 (GND), U32.3 (GND); also elsewhere on the board
LEG_GATE: U30.2 (A); also elsewhere on the board
LEG_IDLE: U30.4 (Y), U31.3 (B)
MCU_CAN_TX: R148.1, U32.2 (A); also elsewhere on the board
N_R88_2: U29.1 (A); also elsewhere on the board

Notes on the sheet:
ACTIVE CAN / HARDWARE TRANSMIT PERMIT
Arm is separate from CAN routing. A low permit releases TXD to its recessive pull-up.
GPIO2 boot strap stays pulled low. Firmware must establish recessive TWAI TX before arming.
Relay gates indicate commanded state. Qualify contact timing and isolation before bench transmission.

Schematic: 28_fault-containment.kicad_sch, Rev D fault containment

Parts:
C151, C152, C153, C154: 100n; C_0603_1608Metric
D45, D46: 1N5819HW-7-F; D_SOD-123
K3, K4: G6K-2F-Y DC5; Relay_DPDT_Omron_G6K-2F-Y
Q29, Q30: AO3400A; SOT-23
R150, R151: 47k; R_0603_1608Metric
R152, R153: 392k 0.5%; R_0603_1608Metric
R154: 100k 1%; R_0603_1608Metric
R155: 68.1k 1%; R_0603_1608Metric
U33: LTC6993HS6-1#TRMPBF; SOT-23-6
U34, U35, U36: SN74LVC1G08DBVR; SOT-23-5

Connections:
+3.3V: C151.1, C152.1, C153.1, C154.1, R154.1, U33.5 (V+), U34.5 (VCC), U35.5 (VCC), U36.5 (VCC); also elsewhere on the board
+5V: D45.1 (K), D46.1 (K), K3.1 (COIL +), K4.1 (COIL +); also elsewhere on the board
CAN_ARM_TIMED: U34.4 (Y); also elsewhere on the board
CAN_BACKUP_COIL: D45.2 (A), K3.8 (COIL -), Q29.3 (D)
CAN_BACKUP_DRIVE: Q29.1 (G), R150.1, U35.4 (Y)
CAN_BRANCH_H: K3.4 (NO A); also elsewhere on the board
CAN_BRANCH_L: K3.5 (NO B); also elsewhere on the board
CAN_DECODE: U35.1 (A); also elsewhere on the board
CAN_SERIES_6: K3.3 (COM A); also elsewhere on the board
CAN_SERIES_14: K3.6 (COM B); also elsewhere on the board
CAN_TIMER_DIV: R154.2, R155.1, U33.4 (DIV)
CAN_TIMER_SET: R152.1, R153.1, U33.3 (SET)
CAN_TIMER_WINDOW: U33.6 (OUT), U34.2 (B)
CAN_TX_ARM: U33.1 (TRIG), U34.1 (A); also elsewhere on the board
GND: C151.2, C152.2, C153.2, C154.2, Q29.2 (S), Q30.2 (S), R150.2, R151.2, R152.2, R153.2, R155.2, U33.2 (GND), U34.3 (GND), U35.3 (GND), U36.3 (GND); also elsewhere on the board
LEGACY_6_ISOLATED: K4.4 (NO A); also elsewhere on the board
LEGACY_14_ISOLATED: K4.5 (NO B); also elsewhere on the board
LEG_BACKUP_COIL: D46.2 (A), K4.8 (COIL -), Q30.3 (D)
LEG_BACKUP_DRIVE: Q30.1 (G), R151.1, U36.4 (Y)
LEG_DECODE: U36.1 (A); also elsewhere on the board
LEG_SERIES_6: K4.3 (COM A); also elsewhere on the board
LEG_SERIES_14: K4.6 (COM B); also elsewhere on the board
N_R88_2: U35.2 (B), U36.2 (B); also elsewhere on the board

Notes on the sheet:
INDEPENDENT SERIES CONTACTS AND HARDWARE CAN TRANSMIT WINDOW
Both switches in a branch must close. A single welded contact leaves the unselected branch isolated.
Positive nonretriggerable pulse. Nominal 1.028 s with both SET resistors. A low arm cancels TX immediately.
